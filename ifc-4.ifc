Properties of the parts of a building model (IFC4)

# File
Description: Hygrostat, Kanal-/Wandmontage, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: JA010200, Hygrostat, Kanal-/Wandmontage, Inneneinstellung
In: Raum
Description: Einsatz in Lüftungs- und Klimakanälen, Klimaschränken und Entfeuchtungsgeräten zur Regelung und/oder Überwachung der Luftfeuchte in Industrie und Landwirtschaft. Nicht geeignet für aggressive Gase. Max. Luftgeschwindigkeit 8 m/s, mit Fühlerschutz FS-HI 15 m/s. Durch die Inneneinstellung besonders geeignet für Installationen, bei denen eine Sollwertverstellung durch unbefugte Personen verhindert werden soll.; Classification: EC011176 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: JA010200; ModelLabel: HI-1F; GlobalTradeItemNumber: 4050528046642; ProductURL: https://alre.de/produkt_JA010200
Pset_Specification - NominalLength: 0.13 m; NominalWidth: 0.071 m; NominalDepth: 0.0675 m; NetWeight: 0.333
Pset_ALRE_ETIM_Properties - Farbe: grau; Breite: 71; Höhe: 130; Tiefe: 67.5; RAL-Nummer: 7035; Explosionsgeschützt: no; Schutzart (IP): IP65; Max. Mediumtemperatur (Dauerbetrieb): 60; Typ Messelement: Kunststoffelement; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 15; Anzahl der Schaltstufen: 1; Messbereich unterer Wert (relative Luftfeuchtigkeit): 30; Messbereich oberer Wert (relative Luftfeuchtigkeit): 100; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011176; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-JA010200.pdf
